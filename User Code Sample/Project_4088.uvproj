# Keil uVision project Project_4088.uvproj, settings and files
target project_flash (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project_4088 +hex
  c flags: Optim=1
  c include: .\Applications;.\Drivers;.\Libraries\CMSIS\Include;.\Libraries\Device\NXP\LPC407x_8x_177x_8x\Include
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Applications
    ./applications/: main.c
  group Drivers
    ./drivers/: drv_led.c
    ./Drivers/: delay.c
  group Libraries
    ./Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ./Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
