# Keil uVision project Project.uvproj, settings and files
target bootloader (ARM-ADS)
  device: LPC1778 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\Applications;.\Drivers;.\Libraries\CMSIS\Include;.\Libraries\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10003000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Applications
    ./applications/: main.c
    ./Applications/: config.h comms.c eth_isp.c spiflash_update.c
  group Drivers
    ./drivers/: drv_led.c
    ./Drivers/: board.c drv_crc.c drv_emac.c drv_iap.c drv_uart.c drv_timer.c drv_spiflash.c drv_spi.c
  group Libraries
    ./Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ./Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
